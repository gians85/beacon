# IAR project gian-beacon.ewp, settings and files
configuration gian-beacon (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: --enable_restrict; -DTOOLCHAIN_object; --guard_calls; --preinclude=mbed_config.h; -DARM_MATH_CM0; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -e; -DTARGET_STMBLUE; -DTARGET_BLUENRG1; -DMBED_BUILD_TIMESTAMP=1518794184.86; -DTARGET_LIKE_CORTEX_M0; -D__CORTEX_M0; -r; -DTARGET_CORTEX_M; -DTARGET_M0; -DTARGET_UVISOR_UNSUPPORTED; --no_wrap_diagnostics; -DTARGET_LIKE_MBED; -DTARGET_DEBUG; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; -DMBED_TRAP_ERRORS_ENABLED=1; -DDEVICE_SERIAL=1; -DMBED_DEBUG; -DTARGET_CORTEX; -D__CMSIS_RTOS; -D__MBED_CMSIS_RTOS_CM; -DTARGET_STEVAL_IDB007V1
  ICCARM.CCIncludePath2: .; .\Beacon_inc; .\Bluetooth_LE; .\Bluetooth_LE\inc; .\Bluetooth_LE\library; .\Bluetooth_LE\Profile_Framework_Central; .\Bluetooth_LE\Profile_Framework_Central\includes; .\Bluetooth_LE\Profile_Framework_Central\library; .\Bluetooth_LE\Profile_Framework_Central\profiles; .\Bluetooth_LE\Profile_Framework_Central\profiles\ble_profile; .\imu_includes; .\mbed-os; .\mbed-os\cmsis; .\mbed-os\cmsis\TARGET_CORTEX_M; .\mbed-os\cmsis\TARGET_CORTEX_M\TOOLCHAIN_IAR; .\mbed-os\drivers; .\mbed-os\features; .\mbed-os\features\filesystem; .\mbed-os\features\filesystem\bd; .\mbed-os\features\filesystem\fat; .\mbed-os\features\filesystem\fat\ChaN; .\mbed-os\features\mbedtls; .\mbed-os\features\mbedtls\importer; .\mbed-os\features\mbedtls\inc; .\mbed-os\features\mbedtls\inc\mbedtls; .\mbed-os\features\mbedtls\platform; .\mbed-os\features\mbedtls\platform\inc; .\mbed-os\features\mbedtls\platform\src; .\mbed-os\features\mbedtls\src; .\mbed-os\features\mbedtls\targets; .\mbed-os\features\nanostack; .\mbed-os\hal; .\mbed-os\hal\storage_abstraction; .\mbed-os\platform; .\mbed-os\targets; .\mbed-os\targets\TARGET_STMBLUE; .\mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG1; .\mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG1\device; .\mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG1\TARGET_STEVAL_IDB007V1; .\mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG1\TARGET_STEVAL_IDB007V1\device; .\mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG1\TARGET_STEVAL_IDB007V1\device\TOOLCHAIN_IAR; .\sdk_hal; .\sdk_hal\inc; .\sdk_hal\src; .\settings; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -D__CORTEX_M0; -D__CMSIS_RTOS; -D__MBED_CMSIS_RTOS_CM; -DARM_MATH_CM0
  OBJCOPY.OOCOutputFile: gian-beacon.hex
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: .\mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG1\TARGET_STEVAL_IDB007V1\device\TOOLCHAIN_IAR\BLUENRG1.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Beacon_inc
    Beacon_inc/: Beacon.cpp Beacon.h Beacon_config.h BlueNRG1_conf.h
  group Bluetooth_LE
    Bluetooth_LE/inc/: ble_const.h ble_status.h bluenrg1_api.h bluenrg1_events.h bluenrg1_gap.h bluenrg1_gatt_server.h bluenrg1_hal.h bluenrg1_stack.h hci_const.h link_layer.h sm.h
    Bluetooth_LE/library/: libbluenrg1_stack.a
    Bluetooth_LE/Profile_Framework_Central/library/: libmaster_library_bluenrg1.a
    Bluetooth_LE/Profile_Framework_Central/includes/: master_basic_profile.h master_basic_profile_events.h master_basic_profile_sm.h
    Bluetooth_LE/Profile_Framework_Central/profiles/ble_profile/: master_events_CB.c
  group gian-beacon
    ./: main.cpp mbed_config.h
  group imu_includes
    imu_includes/: colorlib.h imu.h
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_flash_api.c mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/targets/TARGET_STMBLUE/TARGET_BLUENRG1/TARGET_STEVAL_IDB007V1/device/: BlueNRG1.h bluenrg_x_device.h cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.h system_bluenrg1.c system_bluenrg1.h
    mbed-os/targets/TARGET_STMBLUE/TARGET_BLUENRG1/device/: BlueNRG1_adc.c BlueNRG1_adc.h BlueNRG1_dma.c BlueNRG1_dma.h BlueNRG1_flash.c BlueNRG1_flash.h BlueNRG1_gpio.c BlueNRG1_gpio.h BlueNRG1_i2c.c BlueNRG1_i2c.h BlueNRG1_it.c BlueNRG1_it.h BlueNRG1_mft.c BlueNRG1_mft.h BlueNRG1_pka.c BlueNRG1_pka.h BlueNRG1_rng.c BlueNRG1_rng.h BlueNRG1_rtc.c BlueNRG1_rtc.h BlueNRG1_spi.c BlueNRG1_spi.h BlueNRG1_sysCtrl.c BlueNRG1_sysCtrl.h BlueNRG1_uart.c BlueNRG1_uart.h BlueNRG1_wdg.c BlueNRG1_wdg.h clock.c clock.h misc.c misc.h
    mbed-os/features/filesystem/fat/ChaN/: ccsbcs.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_IAR/: cmain.S
    mbed-os/targets/TARGET_STMBLUE/TARGET_BLUENRG1/TARGET_STEVAL_IDB007V1/: compiler.h objects.h PeripheralNames.h PinNames.h
    mbed-os/targets/TARGET_STMBLUE/TARGET_BLUENRG1/: device.h pin_device.c pin_device.h serial_device.h us_ticker_device.h
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/targets/TARGET_STMBLUE/: gpio_api.c hal_types.h mbed_overrides.c mbed_rtx.h mylib.h pinmap.c serial_api.c serial_mylib.h spi_api.c us_ticker_api.c
    mbed-os/: mbed.h
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/targets/TARGET_STMBLUE/TARGET_BLUENRG1/TARGET_STEVAL_IDB007V1/device/TOOLCHAIN_IAR/: startup_bluenrg1.S
  group sdk_hal
    sdk_hal/inc/: asm.h BlueNRG1_sleep.h crash_handler.h gp_timer.h hal_types.h osal.h
    sdk_hal/src/: BlueNRG1_sleep.c context_switch.s gp_timer.c osal.c
